# Keil uVision project 2_Button.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 2_Button +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c gp_drive.h gp_drive.c systick_time.h systick_time.c uart_drive.c uart_drive.h adc_drive.c adc_drive.h help_func.c help_func.h msg_drive.c msg_drive.h timer_drive.c timer_drive.h cart_move.c cart_move.h read_encoder.c read_encoder.h PID_calculate.c PID_calculate.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
